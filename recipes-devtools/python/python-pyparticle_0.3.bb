include python-pyparticle_0.3.inc

inherit setuptools
