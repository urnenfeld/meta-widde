include python-particle_0.2.inc

inherit pypi setuptools
