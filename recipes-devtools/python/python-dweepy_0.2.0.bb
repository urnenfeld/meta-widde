include dweepy_0.2.0.inc

inherit pypi setuptools
